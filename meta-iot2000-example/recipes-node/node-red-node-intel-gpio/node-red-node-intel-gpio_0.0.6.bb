SUMMARY = "A Node-RED node to talk to an Intel Galileo or Edison using mraa"

# WARNING: the following LICENSE and LIC_FILES_CHKSUM values are best guesses - it is
# your responsibility to verify that the values are complete and correct.
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=2c0cb74248cfa16e787ab1cf4c16e94e"

inherit npm-ng

NPM_LOCAL_INSTALL_DIR = "/home/root/.node-red"
